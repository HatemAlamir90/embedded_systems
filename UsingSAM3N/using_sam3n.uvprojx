# Keil uVision project using_sam3n.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: ATSAM3N4C Atmel
  pack: Keil.SAM3_DFP.1.1.0
  cpu: IROM(0x00400000,0x40000) IRAM(0x20000000,0x06000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: using_sam3n +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Source Group 1
    ./: main.c using_sam3n.c using_sam3n.h
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.0.0
